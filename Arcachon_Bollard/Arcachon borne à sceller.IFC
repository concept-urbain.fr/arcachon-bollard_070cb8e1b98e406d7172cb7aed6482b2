Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Arcachon borne à sceller.IFC
Time: 2020-07-01T12:24:36
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: Arcachon borne à sceller
In: Default Storey
Material: FGS 400-15
PSet_Mass_Property - Mass Measure: 26.4068; Area Measure: 0.788779; Volume Measure: 0.00369326
