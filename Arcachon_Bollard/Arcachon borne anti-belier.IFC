Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Arcachon borne anti-belier.IFC
Time: 2020-07-01T12:24:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: MULT-SCE-001_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: MULT-AB-001_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 36.8476; Area Measure: 1.25099; Volume Measure: 0.00510752
