Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Arcachon borne flexiborne.IFC
Time: 2020-07-01T12:25:29
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: ARCA-BOR-FLE-V2-002_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: ARCA-BOR-AS-001_HS
In: Default Storey
Material: FGS 400-15
PSet_Mass_Property - Mass Measure: 36.1365; Area Measure: 1.26008; Volume Measure: 0.00579378

# IfcBuildingElementProxy: MULT-BOR-FLE-013
In: Default Storey
Material: PE

# IfcBuildingElementProxy: ORMANT-737_Default
In: Default Storey
Material: Steel
